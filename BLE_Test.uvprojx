# Keil uVision project BLE_Test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MKW41Z512xxx4 NXP
  pack: Keil.Kinetis_KWxx_DFP.1.7.0
  cpu: IRAM(0x1FFF8000,0x00020000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: BLE_Test
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x20000
